# Keil uVision project STM32L496ZG_SHT20_DEMO.uvprojx, settings and files
target STM32L496ZG_SHT20_DEMO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496ZG_SHT20_DEMO +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\SHT20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32l4xx_it.c usart.c i2c.c main.c stm32l4xx_hal_msp.c
  group SHT20
    ../SHT20/: SHT20_DRV.c SHT20_DRV.H
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.1.0
